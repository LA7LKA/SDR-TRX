options:
  parameters:
    author: oystein
    generate_options: qt_gui
    id: sdrtrx_freedv1600
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-12000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-12000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=Generic_1,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=J380,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=J380,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=Generic_1,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_1
  id: audio_source
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0_1_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    comment: 'complex band pass: positive keeps USB, negative keeps LSB'
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2700'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/oystein/test_la7lka.wav
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    comment: real IF to analytic
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: vocoder_freedv_rx_ss_0
  id: vocoder_freedv_rx_ss
  parameters:
    interleave_frames: '1'
    mode: freedv_api.MODE_700D
    squelch_enable: 'True'
    squelch_thresh: '-100.0'
  states: {}
- name: vocoder_freedv_tx_ss_0
  id: vocoder_freedv_tx_ss
  parameters:
    clip_val: 'True'
    interleave_frames: '1'
    mode: freedv_api.MODE_700D
    tx_bpf_val: 'True'
    txt_msg: '''GNU Radio'''
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_1, '0', rational_resampler_xxx_0_0, '0']
- [audio_source_0, '0', rational_resampler_xxx_0_0, '0']
- [audio_source_0_0, '0', hilbert_fc_0_0, '0']
- [audio_source_0_1, '0', audio_sink_0_0_1, '0']
- [audio_source_0_1_0, '0', audio_sink_0_0_0, '0']
- [band_pass_filter_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_complex_to_real_0_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_float_to_short_0, '0', vocoder_freedv_tx_ss_0, '0']
- [blocks_float_to_short_0_0, '0', vocoder_freedv_rx_ss_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_short_to_float_0_0, '0', rational_resampler_xxx_0_1, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [hilbert_fc_0_0, '0', blocks_multiply_xx_0_0, '1']
- [rational_resampler_xxx_0, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_float_to_short_0_0, '0']
- [rational_resampler_xxx_0_1, '0', audio_sink_0_0, '0']
- [vocoder_freedv_rx_ss_0, '0', blocks_short_to_float_0_0, '0']
- [vocoder_freedv_tx_ss_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
