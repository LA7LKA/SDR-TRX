options:
  parameters:
    author: LA7LKA
    description: NBFM receiver for checking the transceiver's FM transmit path
    generate_options: qt_gui
    id: nbfm_rx
    output_language: python
    title: NBFM receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: max_dev
  id: variable
  parameters:
    comment: deviation the firmware is set for
    value: '5000'
  states: {}
- name: af_gain
  id: variable
  parameters:
    value: '2'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    samp_rate: samp_rate
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: real IF to analytic
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: negative mixes down
    freq: '-if_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: channel filter, Carson bandwidth
    cutoff_freq: max_dev + 3000
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: gain normalises full deviation to +-1
    gain: samp_rate/(2*3.141592653589793*max_dev)
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: audio
    cutoff_freq: '3000'
    decim: '1'
    gain: af_gain
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '800'
    win: window.WIN_HAMMING
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: watch the deviation here
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    legend: 'False'
    name: baseband
    tr_tag: ''
    type: complex
    ymax: '0'
    ymin: '-120'
    color1: blue
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
