options:
  parameters:
    author: oystein
    generate_options: qt_gui
    id: fm_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: samp_rate
    max_dev: 2.5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 2.5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-12000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-12000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=J380,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=Generic,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=Generic,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=J380,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_1
  id: audio_source
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_1_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/oystein/test_la7lka.wav
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '6000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_nbfm_tx_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0_1, '0', blocks_multiply_xx_0_0_0, '1']
- [audio_source_0, '0', hilbert_fc_0_0, '0']
- [audio_source_0_0, '0', band_pass_filter_0_0, '0']
- [audio_source_0_1, '0', audio_sink_0_0_1, '0']
- [audio_source_0_1_0, '0', audio_sink_0_0_0_0, '0']
- [band_pass_filter_0_0, '0', analog_nbfm_tx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_file_source_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_complex_to_real_0, '0']
- [hilbert_fc_0_0, '0', blocks_multiply_xx_0_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
