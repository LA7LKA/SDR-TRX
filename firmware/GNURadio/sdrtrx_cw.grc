options:
  parameters:
    author: LA7LKA
    description: CW test transmitter, sends CQ CQ CQ DE LA7LKA at the 12 kHz IF
    generate_options: qt_gui
    id: cw_test
    output_language: python
    title: CW test transmitter
  states: {}

blocks:
- name: dit_samples
  id: variable
  parameters:
    value: int(samp_rate * 1.2 / wpm)
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tone
  id: variable
  parameters:
    value: '700'
  states: {}
- name: wpm
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    comment: carrier, IF plus the wanted pitch
    freq: if_freq + tone
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: negative to mix down; a positive frequency would shift up instead
    freq: '-if_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:Generic_1,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=CODEC,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=Generic_1,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_1
  id: audio_source
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_1_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: stretch each dit unit to real time
    interp: dit_samples
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: CQ CQ CQ DE LA7LKA, one value per dit
    repeat: 'True'
    type: float
    vector: '[1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 0.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 0.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 0.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 0.0, 0.0, 0.0, 1.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 0.0, 0.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 0.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 0.0, 1.0, 0.0, 0.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 0.0, 0.0, 0.0, 1.0, 1.0, 1.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 0.0, 0.0, 1.0, 0.0, 1.0, 1.0, 1.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0]'
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: shape the keying edges, no clicks
    cutoff_freq: '80'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '60'
    win: window.WIN_HAMMING
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [audio_source_0_1, '0', audio_sink_0_0_1, '0']
- [audio_source_0_1_0, '0', audio_sink_0_0_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_repeat_0, '0', low_pass_filter_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
