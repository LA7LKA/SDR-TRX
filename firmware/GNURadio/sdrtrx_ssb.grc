options:
  parameters:
    author: LA7LKA
    description: SSB receiver for checking the transceiver's transmit path
    generate_options: qt_gui
    id: ssb_rx
    output_language: python
    title: SSB receiver
  states: {}

blocks:
- name: af_gain
  id: variable
  parameters:
    value: '4'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sb
  id: variable
  parameters:
    comment: 1 for USB, -1 for LSB
    value: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: negative mixes down
    freq: '-if_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: negative mixes down
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse:gnuradio_virtual
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=Generic_1,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    device_name: plughw:CARD=J380,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=Generic_1,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=J380,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0_1
  id: audio_source
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0_1_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    samp_rate: samp_rate
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: 'complex band pass: positive keeps USB, negative keeps LSB'
    decim: '1'
    gain: '1'
    high_cutoff_freq: max(300*sb, 2700*sb)
    low_cutoff_freq: min(300*sb, 2700*sb)
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    comment: 'complex band pass: positive keeps USB, negative keeps LSB'
    decim: '1'
    gain: '1'
    high_cutoff_freq: max(300*sb, 2700*sb)
    low_cutoff_freq: min(300*sb, 2700*sb)
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/oystein/test_la7lka.wav
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: real IF to analytic
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    comment: real IF to analytic
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    comment: both sidebands, for reading the suppression
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    legend: 'False'
    name: baseband
    tr_tag: ''
    type: complex
    update_time: '0.01'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0, '0', band_pass_filter_0_0, '0']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [audio_source_0_0, '0', band_pass_filter_0_0, '0']
- [audio_source_0_1, '0', audio_sink_0_0_1, '0']
- [audio_source_0_1_0, '0', audio_sink_0_0_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [band_pass_filter_0_0, '0', hilbert_fc_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0_0, '0', audio_sink_0_0, '0']
- [blocks_file_source_0, '0', band_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_1, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_complex_to_real_0_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [hilbert_fc_0_0, '0', blocks_multiply_xx_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
