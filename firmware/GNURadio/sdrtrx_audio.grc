options:
  parameters:
    author: oystein
    generate_options: qt_gui
    id: sdrtrx_audio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_1
  id: audio_sink
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_1
  id: audio_source
  parameters:
    device_name: plughw:CARD=Audio,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}
- name: audio_source_0_1_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {}

connections:
- [audio_source_0_1, '0', audio_sink_0_0_1, '0']
- [audio_source_0_1_0, '0', audio_sink_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
