options:
  parameters:
    author: LA7LKA
    description: 'SSB bench flow: RX test-signal generator and TX-verify listener in one flowgraph, switched by the PTT checkbox'
    generate_options: qt_gui
    id: ssb
    output_language: python
    title: SSB bench (RX + TX)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: sb
  id: variable
  parameters:
    comment: 1 for USB, -1 for LSB
    value: '1'
  states: {}
- name: af_gain
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    comment: RX-test modulating tone
    value: '700'
  states: {}
- name: ptt
  id: variable_qtgui_check_box
  parameters:
    comment: Unchecked = RX test (listen to the synthetic IF being demodulated). Checked = TX test (listen to what the STM32 transmitted). Space toggles it once it has keyboard focus, same as any Qt checkbox.
    label: PTT (TX)
    press_value: '1'
    release_value: '0'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    comment: RX-test modulating tone
    freq: tone_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: modulator - real tone to analytic
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: upconvert carrier; sign of if_freq*sb picks USB/LSB
    freq: if_freq*sb
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: level into the soundcard, not af_gain (that is the demod side)
    const: '0.3'
    type: float
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    comment: demod - real IF to analytic
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: negative mixes down
    freq: '-if_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: 'complex band pass: positive keeps USB, negative keeps LSB'
    decim: '1'
    gain: '1'
    high_cutoff_freq: max(300*sb, 2700*sb)
    low_cutoff_freq: min(300*sb, 2700*sb)
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    comment: final audio cleanup
    decim: '1'
    gain: '1'
    high_cutoff_freq: '2500'
    low_cutoff_freq: '400'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: audio_sink_generic
  id: audio_sink
  parameters:
    comment: ch0 (L) -> STM32 PC0 (RX IF in). ch1 (R) -> STM32 PA3 (TX mic in)
    device_name: plughw:CARD=Generic,DEV=0
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_source_generic
  id: audio_source
  parameters:
    comment: ch0 (L) <- STM32 DAC1/PA4 (RX audio out). ch1 (R) <- STM32 DAC2/PA5 (TX IF out)
    device_name: plughw:CARD=Generic,DEV=0
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_source_jabra
  id: audio_source
  parameters:
    comment: operator mic, passed straight through to the STM32's mic input
    device_name: plughw:CARD=J380,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_sink_jabra
  id: audio_sink
  parameters:
    comment: operator headphones - hears whichever branch ptt selects
    device_name: plughw:CARD=J380,DEV=0
    samp_rate: samp_rate
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: 'ptt=0: monitor the RX-test demod. ptt=1: monitor the TX-verify demod'
    enabled: 'True'
    input_index: ptt
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_generic, '0']
- [audio_source_jabra, '0', audio_sink_generic, '1']
- [audio_source_generic, '1', hilbert_fc_1, '0']
- [hilbert_fc_1, '0', blocks_multiply_xx_1, '0']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_1, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_real_1, '0']
- [blocks_complex_to_real_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', band_pass_filter_1, '0']
- [band_pass_filter_1, '0', blocks_selector_0, '1']
- [audio_source_generic, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', audio_sink_jabra, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
