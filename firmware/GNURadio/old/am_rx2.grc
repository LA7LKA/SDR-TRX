options:
  parameters:
    author: LA7LKA
    description: AM receiver using the demod chain proven in am_loopback -- envelope via complex_to_mag plus a DC blocker, not analog_am_demod_cf.
    generate_options: qt_gui
    id: am_rx2
    output_language: python
    title: AM receiver (proven demod)
  states: {}

blocks:
- name: af_gain
  id: variable
  parameters:
    value: '2'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: mix down
    freq: '-if_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: your speakers, NOT the radio card
    device_name: plughw:CARD=CODEC,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: radio IF in
    device_name: plughw:CARD=CODEC,DEV=0
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    comment: envelope -- the piece that works
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: remove carrier pedestal
    length: '256'
    long_form: 'True'
    type: ff
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: real -> analytic
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: AM channel, symmetric about DC
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: recovered audio -- the tone/voice should appear
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    legend: 'False'
    name: recovered audio
    tr_tag: ''
    type: float
    ymin: '-100'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
