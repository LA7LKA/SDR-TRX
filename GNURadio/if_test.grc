options:
  parameters:
    author: oystein
    generate_options: qt_gui
    id: if_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=USB,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=CODEC,DEV=0
    samp_rate: samp_rate
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/oystein/test_la7lka.wav
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.3'
    interp: '10'
    type: ccc
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: 5e6
    center_freq: 432.525e6-12000
    dev_args: driver=lime
    gain: '64'
    samp_rate: '480000'
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [audio_source_0, '0', hilbert_fc_0_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', audio_sink_0, '0']
- [hilbert_fc_0_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
