options:
  parameters:
    author: LA7LKA
    description: FreeDV 2400B receiver -- FM path, for checking 2400B transmit
    generate_options: qt_gui
    id: freedv_2400b_rx
    output_language: python
    title: FreeDV 2400B receiver
  states: {}

blocks:
- name: af_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: max_dev
  id: variable
  parameters:
    comment: same 2.5 kHz the radio transmits
    value: '2500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM discriminator -- the piece SSB rx lacks
    gain: samp_rate/(2*3.141592653589793*max_dev)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: negative mixes down
    freq: '-if_freq'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: keep off the card feeding the radio mic
    device_name: plughw:CARD=CODEC,DEV=0
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: plughw:CARD=CODEC,DEV=0
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    comment: 2400B modem is 48k, no resampling
    scale: '16384'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    comment: speech is 8k
    scale: '16384'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    comment: real IF to analytic
    num_taps: '129'
    win: window.WIN_HANN
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: FM channel, Carson
    cutoff_freq: '6000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: 8k -> 48k
    decim: '1'
    interp: '6'
    type: fff
  states: {}
- name: vocoder_freedv_rx_ss_0
  id: vocoder_freedv_rx_ss
  parameters:
    comment: must be 2400B
    interleave_frames: '1'
    mode: freedv_api.MODE_2400B
    squelch_enable: 'True'
    squelch_thresh: '-100.0'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_short_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [audio_source_0, '0', hilbert_fc_0, '0']
- [blocks_float_to_short_0, '0', vocoder_freedv_rx_ss_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [vocoder_freedv_rx_ss_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
